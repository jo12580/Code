# Keil uVision project STM32-DEMO.uvprojx, settings and files
target lcd240128 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c SysTickDelay.c LCM240128.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 4.3.0

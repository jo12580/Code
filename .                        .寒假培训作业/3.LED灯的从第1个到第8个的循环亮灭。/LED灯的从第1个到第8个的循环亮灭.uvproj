# Keil uVision project LED灯的从第1个到第8个的循环亮灭.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED灯的从第1个到第8个的循环亮灭 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED灯的从第1个到第8个的循环亮灭.c

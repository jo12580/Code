# Keil uVision project test-74HC595.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT87F52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(24000000)
  output: test-74HC595 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c IIC-1602.c

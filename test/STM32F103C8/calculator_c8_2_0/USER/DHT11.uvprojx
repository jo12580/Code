# Keil uVision project DHT11.uvprojx, settings and files
target DHT11 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DHT11 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIME;..\HARDWARE\GUI;..\HARDWARE\IIC;..\HARDWARE\OLED;..\HARDWARE\Calculator
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
    ../STM32F10x_FWLib/src/: stm32f10x_tim.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ./: system_stm32f10x.c
    ../HARDWARE/TIME/: time.c
    ../HARDWARE/GUI/: gui.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/Calculator/: calculator.c linkstack.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_i2c.c
  group README
    ../: README.TXT
